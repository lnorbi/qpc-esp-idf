# IAR project game-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFM32PG1B200F256GM48
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\ports\arm-cm\qk\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\efm32pg1b
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: game-qk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: game-qk.out
  ILINK.IlinkIcfFile: game-qk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; EFM32PG1B200F256GM48
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: Q_SPY; EFM32PG1B200F256GM48
  group Application
    ../: bsp.c
    ../../: bsp.h game.h main.c mine1.c mine2.c missile.c ship.c tunnel.c
    ../../../../../src/qs/: qstamp.c
  group efm32pg1b
    ../../../../../3rd_party/efm32pg1b/: display_ls013b7dh03.c display_ls013b7dh03.h displaypalemlib.c em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_prs.c em_rtcc.c em_system.c em_usart.c system_efm32pg1b.c udelay.c
    ../../../../../3rd_party/efm32pg1b/iar/: startup_efm32pg1b.s
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/: qf_pkg.h qk_pkg.h
    ../../../../../src/qk/: qk.c
  group QP_port
    ../../../../../ports/arm-cm/qk/iar/: qk_port.c
  group QS
    ../../../../../src/qs/: qs.c qs_fp.c qs_rx.c
    ../../../../../src/: qs_pkg.h
